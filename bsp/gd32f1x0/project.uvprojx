# Keil uVision project project.uvprojx, settings and files
target rtthread-gd32f1x0 (5060020::V5.06 (build 20)::ARMCC)
  device: GD32F150C8 GigaDevice
  pack: Keil.GD32F1xx_DFP.1.0.1
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x02000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: rtthread-gd32f1x0
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: GD32F1x0, USE_STDPERIPH_DRIVER, GD32F130_150
  c include: applications;.;drivers;Libraries\Peripherals\inc;Libraries\CMSIS;..\..\components\CMSIS\Include;..\..\include;..\..\libcpu\arm\cortex-m3;..\..\libcpu\arm\common;..\..\components\drivers\include;..\..\components\drivers\include
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  link misc: --keep *.o(.rti_fn.*)
  group Applications
    applications/: application.c startup.c
  group Drivers
    drivers/: board.c gd32f1x0_it.c
  group GD32_StdPeriph
    Libraries/CMSIS/: system_gd32f1x0.c
    Libraries/Peripherals/src/: gd32f1x0_adc.c gd32f1x0_can.c gd32f1x0_cec.c gd32f1x0_cmp.c gd32f1x0_crc.c gd32f1x0_dac.c gd32f1x0_dma.c gd32f1x0_exti.c gd32f1x0_fmc.c gd32f1x0_gpio.c gd32f1x0_i2c.c gd32f1x0_ivref.c gd32f1x0_iwdg.c gd32f1x0_lcd.c gd32f1x0_mcudbg.c gd32f1x0_misc.c gd32f1x0_opamp.c gd32f1x0_pwr.c gd32f1x0_rcc.c gd32f1x0_rtc.c gd32f1x0_spi.c gd32f1x0_syscfg.c gd32f1x0_timer.c gd32f1x0_tsi.c gd32f1x0_usart.c gd32f1x0_wwdg.c
    Libraries/CMSIS/ARM/: startup_gd32f1x0.s
  group Kernel
    ../../src/: clock.c components.c device.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler.c thread.c timer.c
  group CORTEX-M3
    ../../libcpu/arm/cortex-m3/: cpuport.c context_rvds.S
    ../../libcpu/arm/common/: backtrace.c div0.c showmem.c
  group DeviceDrivers
    ../../components/drivers/serial/: serial.c
    ../../components/drivers/src/: completion.c dataqueue.c pipe.c portal.c ringbuffer.c workqueue.c
