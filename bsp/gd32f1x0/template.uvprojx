# Keil uVision project template.uvprojx, settings and files
target rtthread-gd32f1x0 (ARM-ADS)
  device: GD32F150C8 GigaDevice
  pack: Keil.GD32F1xx_DFP.1.0.1
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x02000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: rtthread-gd32f1x0
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=1 OneElfS=1 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
