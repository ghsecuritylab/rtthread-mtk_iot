# Keil uVision project project.uvprojx, settings and files
target RT-Thread MTK-IOT (5060020::V5.06 (build 20)::ARMCC)
  device: MT7687F MediaTek
  pack: MediaTek.MTx.4.6.0
  cpu: IROM(0x10000000,0x00200000) IRAM(0x20000000,0x00040000) IRAM2(0x00100000,0x00010000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: rtthread-mt76xx
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=4 uC99=1
  c define: MTK_DEBUG_LEVEL_NONE __BT_DEBUG__ MTK_HCI_CONSOLE_MIX_ENABLE MTK_MINISUPP_ENABLE MTK_BSPEXT_ENABLE MTK_LWIP_ENABLE PRODUCT_VERSION=7697 MTK_FLASH_DIRECT_DL MTK_PATCH_DL_ENABLE  MTK_WIFI_REPEATER_ENABLE  MTK_DEBUG_LEVEL_INFO  MTK_WIFI_PRIVILEGE_ENABLE MBEDTLS_CONFIG_FILE=<config-mtk-md5.h>
  c include: applications;.;drivers;Libraries\startup;Libraries\startup\mt7687;Libraries\driver\CMSIS\Include;Libraries\driver\CMSIS\Device\MTK\mt7687\Include;Libraries\driver\chip\mt7687\inc;Libraries\driver\chip\mt7687\src\common\include;Libraries\driver\chip\inc;Libraries\driver\chip\mt7687\inc;Libraries\driver\chip\mt7687\src\common\include;Libraries\driver\chip\mt7687\src_core;Libraries\driver\chip\mt7687\src_core\MDK-ARM\libhal_core_CM4_Keil\inc;Libraries\driver\board\mt76x7_hdk\external_flash\inc;Libraries\driver\board\mt76x7_hdk\ept\inc;Libraries\middleware\MTK\connsys\inc;Libraries\middleware\MTK\wifi_service\combo\inc;Libraries\kernel\service\inc;Libraries\middleware\MTK\dhcpd\inc;Libraries\prebuilt\middleware\MTK\minisupp\inc;..\..\include;..\..\libcpu\arm\cortex-m4;..\..\libcpu\arm\common;..\..\components\drivers\include;..\..\components\drivers\spi;..\..\components\drivers\include;..\..\components\drivers\include;..\..\components\net\lwip-2.0.2\src;..\..\components\net\lwip-2.0.2\src\include;..\..\components\net\lwip-2.0.2\src\include\ipv4;..\..\components\net\lwip-2.0.2\src\arch\include;..\..\components\net\lwip-2.0.2\src\include\netif
  library: MicroLIB
  memory RVCT4: ROM 0x10000000 size 0x400000
  memory RVCT9: RAM 0x20000000 size 0x40000
  memory RVCT10: RAM 0x100000 size 0x10000
  scatter file: .\flash.sct
  group Applications
    applications/: application.c startup.c
  group Drivers
    drivers/: ept_eint_var.c ept_gpio_var.c fmq.c fport.c mtk_wifi_drv.c netio.c network_default_config.c regions_init.c sys_init.c system_mt7687.c wifi_lwip_helper.c
    ./Libraries/prebuilt/middleware/MTK/wifi_service/combo/lib/wifi_supp/: libwifi_CM4_Keil.lib
    ./Libraries/prebuilt/middleware/MTK/minisupp/lib/: libminisupp_CM4_Keil.lib
    ./Libraries/prebuilt/driver/chip/mt7687/lib/: libhal_protected_CM4_Keil.lib
  group Libraries
    Libraries/driver/board/mt76x7_hdk/ept/src/: bsp_gpio_ept_config.c
    Libraries/driver/board/mt76x7_hdk/external_flash/src/: bsp_flash_config.c
    Libraries/driver/chip/mt7687/src/common/: cos_api.c dma.c flash_sfc.c gpt.c hal_I2C.c hal_gpc.c hal_gpio_7687.c hal_i2s_internal.c hal_irrx.c hal_lp.c hal_pcnt.c hal_pinmux.c hal_spim.c hal_sys.c hal_trng.c hal_uid.c i2c.c ir_tx.c low_hal_gpio.c low_hal_irrx.c low_hal_irtx.c low_hal_pwm.c low_hal_rtc.c low_hal_wdt.c nvic.c pinmux.c pwm.c sfc.c spi_flash.c spim.c timer.c top.c uart.c
    Libraries/driver/chip/mt7687/src/: hal_adc.c hal_aes.c hal_audio_internal_service.c hal_cache.c hal_cache_internal.c hal_des.c hal_dwt.c hal_eint.c hal_flash.c hal_gdma.c hal_gpio.c hal_gpt.c hal_i2c_master.c hal_i2s.c hal_irtx.c hal_log.c hal_md5.c hal_misc.c hal_mpu.c hal_mpu_internal.c hal_nvic.c hal_nvic_internal.c hal_pwm.c hal_rtc.c hal_sha.c hal_spi_master.c hal_spi_slave.c hal_uart.c hal_wdt.c hci_log.c
    Libraries/driver/chip/mt7687/src_core/: hal_efuse.c hal_sleep_driver.c hal_sleep_manager.c
    Libraries/middleware/MTK/wifi_service/combo/src/wifi_os_ext/: os_util.c os_utils.c
    Libraries/middleware/MTK/wifi_service/combo/src/: misc.c inband_queue_option.c wifi_os_api.c wifi_profile.c get_profile_string.c
    Libraries/middleware/MTK/wifi_service/combo/src/init/: wifi_init.c wifi_default_config.c
    Libraries/kernel/service/src/: syslog.c
    Libraries/middleware/MTK/connsys/src/: connsys_driver.c connsys_bus.c connsys_util.c
    Libraries/middleware/MTK/dhcpd/src/: dhcpd.c
    Libraries/startup/mt7687/mdk-arm/: startup_mt7687.s
  group Kernel
    ../../src/: clock.c device.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler.c thread.c timer.c
  group CORTEX-M4
    ../../libcpu/arm/cortex-m4/: cpuport.c context_rvds.S
    ../../libcpu/arm/common/: backtrace.c div0.c showmem.c
  group DeviceDrivers
    ../../components/drivers/serial/: serial.c
    ../../components/drivers/spi/: spi_core.c spi_dev.c
    ../../components/drivers/src/: completion.c dataqueue.c pipe.c portal.c ringbuffer.c workqueue.c
  group lwIP
    ../../components/net/lwip-2.0.2/src/arch/: sys_arch.c
    ../../components/net/lwip-2.0.2/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    ../../components/net/lwip-2.0.2/src/core/: def.c dns.c inet_chksum.c init.c ip.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
    ../../components/net/lwip-2.0.2/src/netif/: ethernet.c ethernetif.c lowpan6.c
    ../../components/net/lwip-2.0.2/src/core/ipv4/: autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
