# Keil uVision project template.uvprojx, settings and files
target RT-Thread MTK-IOT (5060020::V5.06 (build 20)::ARMCC)
  device: MT7687F MediaTek
  pack: MediaTek.MTx.4.6.0
  cpu: IROM(0x10000000,0x00200000) IRAM(0x20000000,0x00040000) IRAM2(0x00100000,0x00010000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: rtthread-mt76xx
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=4 uC99=1
  library: MicroLIB
  memory RVCT4: ROM 0x10000000 size 0x400000
  memory RVCT9: RAM 0x20000000 size 0x40000
  memory RVCT10: RAM 0x100000 size 0x10000
  scatter file: .\flash.sct
  link misc: --entry Reset_Handler --first __isr_vector
