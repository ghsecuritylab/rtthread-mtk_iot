# Keil uVision project project.uvprojx, settings and files
target RT-Thread MTK-IOT (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: MT7687F MediaTek
  pack: MediaTek.MTx.4.5.0
  cpu: IROM(0x10000000,0x00200000) IRAM(0x20000000,0x00040000) IRAM2(0x00100000,0x00010000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: rtthread-mt76xx
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=4 uC99=1
  c define: MTK_DEBUG_LEVEL_NONE PRODUCT_VERSION=7697 CFG_SUPPORT_SMNT_PROTO=2 MTK_HAL_NO_LOG_ENABLE MTK_MINISUPP_ENABLE MTK_WIFI_PRIVILEGE_ENABLE
  c include: applications;.;drivers;Libraries\startup;Libraries\startup\mt7687;Libraries\driver\CMSIS\Include;Libraries\driver\CMSIS\Device\MTK\mt7687\Include;Libraries\driver\chip\mt7687\inc;Libraries\driver\chip\mt7687\src\common\include;Libraries\driver\chip\inc;Libraries\driver\chip\inc;Libraries\driver\chip\mt7687\inc;Libraries\driver\chip\mt7687\src\common\include;Libraries\driver\chip\mt7687\src_core;Libraries\driver\chip\mt7687\src_core\MDK-ARM\libhal_core_CM4_Keil\inc;Libraries\driver\board\mt76x7_hdk\external_flash\inc;Libraries\driver\board\mt76x7_hdk\ept\inc;Libraries\middleware\MTK\connsys\inc;Libraries\kernel\service\inc;..\..\..\rt-thread\include;..\..\..\rt-thread\libcpu\arm\cortex-m4;..\..\..\rt-thread\libcpu\arm\common;..\..\..\rt-thread\components\drivers\include;..\..\..\rt-thread\components\drivers\include;..\..\..\rt-thread\components\finsh
  library: MicroLIB
  memory RVCT4: ROM 0x10000000 size 0x400000
  memory RVCT9: RAM 0x20000000 size 0x40000
  memory RVCT10: RAM 0x100000 size 0x10000
  scatter file: .\flash.sct
  link misc: --keep *.o(FSymTab) --keep *.o(VSymTab)
  group Applications
    applications/: application.c startup.c
  group Drivers
    drivers/: board.c
    ./drivers/: usart.c
  group Libraries
    Libraries/startup/: system_mt7687.c sys_init.c
    Libraries/driver/board/mt76x7_hdk/ept/src/: bsp_gpio_ept_config.c
    Libraries/driver/board/mt76x7_hdk/external_flash/src/: bsp_flash_config.c
    Libraries/driver/chip/mt7687/src/common/: cos_api.c dma.c flash_sfc.c gpt.c hal_I2C.c hal_gpc.c hal_gpio_7687.c hal_i2s_internal.c hal_irrx.c hal_lp.c hal_pcnt.c hal_pinmux.c hal_spim.c hal_sys.c hal_trng.c hal_uid.c i2c.c ir_tx.c low_hal_gpio.c low_hal_irrx.c low_hal_irtx.c low_hal_pwm.c low_hal_rtc.c low_hal_wdt.c nvic.c pinmux.c pwm.c sfc.c spi_flash.c spim.c timer.c top.c uart.c
    Libraries/driver/chip/mt7687/src/: hal_adc.c hal_aes.c hal_audio_internal_service.c hal_cache.c hal_cache_internal.c hal_des.c hal_dwt.c hal_eint.c hal_flash.c hal_gdma.c hal_gpio.c hal_gpt.c hal_i2c_master.c hal_i2s.c hal_irtx.c hal_log.c hal_md5.c hal_misc.c hal_mpu.c hal_mpu_internal.c hal_nvic.c hal_nvic_internal.c hal_pwm.c hal_rtc.c hal_sha.c hal_spi_master.c hal_spi_slave.c hal_uart.c hal_wdt.c hci_log.c
    Libraries/driver/chip/mt7687/src_core/: hal_efuse.c hal_sleep_driver.c hal_sleep_manager.c
    Libraries/kernel/service/src/: syslog.c
    Libraries/startup/mt7687/mdk-arm/: startup_mt7687.s
    Libraries/prebuilt/driver/chip/mt7687/lib/: libhal_protected_CM4_Keil.lib
  group Kernel
    ../../../rt-thread/src/: clock.c device.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler.c thread.c timer.c
  group CORTEX-M4
    ../../../rt-thread/libcpu/arm/cortex-m4/: cpuport.c context_rvds.S
    ../../../rt-thread/libcpu/arm/common/: backtrace.c div0.c showmem.c
  group DeviceDrivers
    ../../../rt-thread/components/drivers/serial/: serial.c
    ../../../rt-thread/components/drivers/src/: completion.c dataqueue.c pipe.c portal.c ringbuffer.c workqueue.c
  group finsh
    ../../../rt-thread/components/finsh/: shell.c symbol.c cmd.c finsh_compiler.c finsh_error.c finsh_heap.c finsh_init.c finsh_node.c finsh_ops.c finsh_parser.c finsh_var.c finsh_vm.c finsh_token.c
